FILES_mtd-utils-ubifs += " ${sbindir}/nandwrite ${sbindir}/flash_erase"